Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-08-08T16:11:31
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Aug 08 16:11:31 2023 * Host: ZIL5CD2317NJM * Database: C:\Users\MKhan\AppData\Local\Temp\ae1c442d-0e26-4bde-a6b2-8f373bae26f6\b05cbf0d-678d-4d6e-8c53-a3aa31904f94\ifc * Database version: 5507 * Database creation date: Tue Aug 08 16:11:30 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Aug 08 16:11:30 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Aug 08 16:11:30 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: SLFADA2225A55-J_Just_Sink_Drop-In:SLFADA2225A55-J, SLFADA2225A55-J_Just_Sink_Drop-In:SLFADA2225A55-J:811961
In: Level 1
Type - Material: 304 Stainless Steel, Stainless Steel
Type - Pset_DistributionFlowElementCommon - Reference: SLFADA2225A55-J
Type - Pset_ElectricalDeviceCommon - IP_Code: n/a; InsulationStandardClass: n/a
Type - Pset_ElementShading - Color: 304 Stainless Steel
Type - Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Name: Sink_SLFADA2225A55-J; Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: SLFADA2225A55-J
Material: Stainless Steel
Pset_DistributionFlowElementCommon - sets with these values: 2
